# IAR project SOLOWHEEL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..; ..\..\STM32F10XFWLIB\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SOLOWHEEL.bin
  ILINK.IlinkOutputFile: SOLOWHEEL.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: ..\SWRelease.bin
  ILINK.IlinkOutputFile: SWRelease.out
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group include
    ../inc/: MC_Clarke_Park.h MC_const.h MC_Display.h MC_FOC_Drive.h MC_Globals.h MC_MotorControl_Layer.h MC_PID_regulators.h MC_type.h motion.h stm32f10x_hall.h stm32f10x_MClib.h stm32f10x_svpwm_ics.h stm32f10x_Timebase.h
    ../../STM32F10XFWLIB/inc/: stm32f10x_usart.h
  group Parameters .h files
    ../inc/: MC_Control_Param.h MC_hall_prm.h MC_pwm_ics_prm.h
  group source
    ../src/: main.c MC_Clarke_Park.c MC_Display.c MC_FOC_Drive.c MC_Globals.c MC_MotorControl_Layer.c MC_PID_regulators.c motion.c stm32f10x_hall.c stm32f10x_svpwm_ics.c stm32f10x_Timebase.c
    ./: stm32f103x8.icf
    ../: stm32f10x_it.c
  group STM32F10XFWLIB
    ../../STM32F10XFWLIB/inc/: MC_FOC_Methods.o MC_State_Observer.o
    ../../STM32F10XFWLIB/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
